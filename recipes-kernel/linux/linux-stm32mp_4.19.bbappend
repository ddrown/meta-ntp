FILESEXTRAPATHS_prepend := "${THISDIR}:"
KERNEL_CONFIG_FRAGMENTS += "${WORKDIR}/fragments/4.19/pps.config"
SRC_URI += "file://4.19/pps.config;subdir=fragments;name=ppsconfig"
SRC_URI_class-devupstream += " file://4.19/pps.config;subdir=fragments "
SRC_URI[ppsconfig.md5sum] = "cc5cc4a689d31dedc39d6e70ea7ba2ce"
SRC_URI[ppsconfig.sha256sum] = "bb57a68a824e16079e38896b310cc7b0349d83e0c2a80e78ed1773e2f5fdcd4e"
